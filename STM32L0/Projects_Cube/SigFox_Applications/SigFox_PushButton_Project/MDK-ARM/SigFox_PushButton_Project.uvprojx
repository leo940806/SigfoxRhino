# Keil uVision project SigFox_PushButton_Project.uvprojx, settings and files
target NUCLEO_L1_ALL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_ALL_NUCLEO_L1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ALL
  c misc: --diag_suppress=951 --wchar32
  c include: ..\Source;..\..\common\id_key_retriever;..\..\common\st_lowlevel;..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Inc;..\..\..\..\Drivers\BSP\STM32_Nucleo\Inc;..\MDK-ARM;..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0;..\Source\STM32\inc;..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --no_strict_wchar_size
  group Source
    ../Source/: main.c hw_config.c
    ../../common/st_lowlevel/: nvm_api.c
  group Source\BlueNRG
    ../Source/BlueNRG/src/: BlueNRG1_it.c
    ../../common/st_lowlevel/: mcu_api_bluenrg1.c
  group Source\STM32
    ../Source/STM32/src/: stm32f0xx_it.c stm32f4xx_it.c stm32l0xx_it.c stm32l1xx_it.c
    ../../common/st_lowlevel/: mcu_api.c
  group Drivers STM32
    ../../../../Drivers/BSP/Components/S2LP/STM32_Nucleo_S2LP_Util/Src/: S2LP_SDK_Util.c
    ../../../../Drivers/BSP/STM32_Nucleo/Src/: SDK_EVAL_Button.c SDK_EVAL_Config.c SDK_EVAL_EEPROM.c SDK_EVAL_Gpio.c SDK_EVAL_Led.c SDK_EVAL_Spi_Driver_DMA.c SDK_EVAL_Timers.c SDK_EVAL_EMB_FLASH.c
  group Drivers BlueNRG
    ../../../../Drivers/BSP/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c
    ../../../../Drivers/BSP/SDK_Eval_S2LP_BlueNRG1/src/: S2LP_EVAL_Button.c S2LP_EVAL_Config.c S2LP_EVAL_EEPROM_DMA.c S2LP_EVAL_EMB_FLASH.c S2LP_EVAL_Gpio.c S2LP_EVAL_SPI_DMA.c S2LP_EVAL_Utils.c
  group Libraries_CM3
    ../../../../Middlewares/Sigfox/CM3/: ST_RF_LIB_ALL_CM3.a ST_RF_LIB_ARIB_CM3.a ST_RF_LIB_ETSI_CM3.a ST_RF_LIB_FCC_CM3.a SFX_LIB_V2.5.0_FDL_Cortex_M3.a
    ../../common/id_key_retriever/CM3/: ID_KEY_RETRIEVER_CM3.a
  group Libraries_CM0
    ../../../../Middlewares/Sigfox/CM0/: ST_RF_LIB_ALL_CM0.a ST_RF_LIB_ARIB_CM0.a ST_RF_LIB_ETSI_CM0.a ST_RF_LIB_FCC_CM0.a SFX_LIB_V2.5.0_FDL_Cortex_M0.a
    ../../common/id_key_retriever/CM0/: ID_KEY_RETRIEVER_CM0.a
  group Libraries_CM0+
    ../../../../Middlewares/Sigfox/CM0PLUS/: ST_RF_LIB_ALL_CM0+.a ST_RF_LIB_ARIB_CM0+.a ST_RF_LIB_ETSI_CM0+.a ST_RF_LIB_FCC_CM0+.a SFX_LIB_V2.5.0_FDL_Cortex_M0+.a SFX_ADDON_VERIFIED_V0.4.0_FDL_Cortex_M0+.a
    ../../common/id_key_retriever/CM0PLUS/: ID_KEY_RETRIEVER_CM0+.a
  group Libraries_CM4
    ../../../../Middlewares/Sigfox/CM4/: ST_RF_LIB_ALL_CM4.a ST_RF_LIB_ARIB_CM4.a ST_RF_LIB_ETSI_CM4.a ST_RF_LIB_FCC_CM4.a SFX_LIB_V2.5.0_FDL_Cortex_M4.a
    ../../common/id_key_retriever/CM4/: ID_KEY_RETRIEVER_CM4.a
  group STM32L1xx_HAL
    ../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c
  group STM32L0xx_HAL
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_wwdg.c
  group STM32F0xx_HAL
    ../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group STM32F4xx_HAL
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
  group BlueNRG1_HAL
    ../../../../Drivers/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
    ../../../../Drivers/HAL_BLUENRG/src/: clock.c osal.c sleep.c
  group Device
    ./: startup_stm32l152xe.s startup_stm32l053xx.s startup_stm32f072xb.s startup_stm32f401xe.s startup_stm32l051xx.s
    ../../../../Drivers/HAL_BLUENRG/src/: context_switch.s
    ../Source/STM32/src/: system_stm32f0xx.c system_stm32f4xx.c system_stm32l0xx.c system_stm32l1xx.c
    ../../../../Drivers/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group Rhino
    ../../../../Rhino/: gps.c lis2de.c gps.h lis2de.h linkdata.c linkdata.h
  group Ubiscale
    ../../../../Ubiscale/: libubignsscore.a libubignsscore.h uart_driver.h timer_driver.h timer_driver.c uart_driver.c ubignss.c ubignss.h
target NUCLEO_L1_ETSI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.2.1.0
  cpu: as above
  output: ST_SIGFOX_PB_ETSI_NUCLEO_L1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ETSI
  c misc: --diag_suppress=951 --wchar32
  c include: ..\Source;..\..\common\id_key_retriever;..\..\common\st_lowlevel;..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Inc;..\..\..\..\Drivers\BSP\STM32_Nucleo\Inc;..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\MDK-ARM;..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0;..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\Source\STM32\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --no_strict_wchar_size
target NUCLEO_L1_FCC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.2.1.0
  cpu: as above
  output: ST_SIGFOX_PB_FCC_NUCLEO_L1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_FCC
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --no_strict_wchar_size
target NUCLEO_L1_ARIB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.2.1.0
  cpu: as above
  output: ST_SIGFOX_PB_ARIB_NUCLEO_L1 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ARIB
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --no_strict_wchar_size
target NUCLEO_L0_ALL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L051K8Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_ALL_NUCLEO_L0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L051xx USE_STM32L0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ALL USE_FLASH INCLUDE_WWDG
  c misc: --diag_suppress=951 --wchar32
  c include: ..\Source;..\..\common\id_key_retriever;..\..\common\st_lowlevel;..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Inc;..\..\..\..\Drivers\BSP\STM32_Nucleo\Inc;..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\MDK-ARM;..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0;..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\Source\STM32\inc;..\..\..\..\Rhino;..\..\..\..\Ubiscale;..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --no_strict_wchar_size
target NUCLEO_L0_ETSI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L053R8Hx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: as above
  output: ST_SIGFOX_PB_ETSI_NUCLEO_L0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx USE_STM32L0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ETSI
  c misc: --diag_suppress=951 --wchar32
  c include: ..\Source;..\..\common\id_key_retriever;..\..\common\st_lowlevel;..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Inc;..\..\..\..\Drivers\BSP\STM32_Nucleo\Inc;..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\MDK-ARM;..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0;..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\Source\STM32\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --no_strict_wchar_size
target NUCLEO_L0_FCC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L053R8Hx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: as above
  output: ST_SIGFOX_PB_FCC_NUCLEO_L0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx USE_STM32L0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_FCC
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --no_strict_wchar_size
target NUCLEO_L0_ARIB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L053R8Hx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: as above
  output: ST_SIGFOX_PB_ARIB_NUCLEO_L0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx USE_STM32L0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ARIB
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --no_strict_wchar_size
target NUCLEO_F0_ALL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_ALL_NUCLEO_F0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB USE_STM32F0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ALL
  c misc: --diag_suppress=951 --wchar32
  c include: ..\Source;..\..\common\id_key_retriever;..\..\common\st_lowlevel;..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Inc;..\..\..\..\Drivers\BSP\STM32_Nucleo\Inc;..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\MDK-ARM;..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\Source\STM32\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --no_strict_wchar_size
target NUCLEO_F0_ETSI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072RBHx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: as above
  output: ST_SIGFOX_PB_ETSI_NUCLEO_F0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB USE_STM32F0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ETSI
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --no_strict_wchar_size
target NUCLEO_F0_FCC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072RBHx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: as above
  output: ST_SIGFOX_PB_FCC_NUCLEO_F0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB USE_STM32F0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_FCC
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --no_strict_wchar_size
target NUCLEO_F0_ARIB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: as above
  output: ST_SIGFOX_PB_ARIB_NUCLEO_F0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB USE_STM32F0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ARIB
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --no_strict_wchar_size
target NUCLEO_F4_ALL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_ALL_NUCLEO_F4 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xE USE_STM32F4XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ALL ERASE_VALUE_IS_FF
  c misc: --diag_suppress=951 --wchar32
  c include: ..\Source;..\..\common\id_key_retriever;..\..\common\st_lowlevel;..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Inc;..\..\..\..\Drivers\BSP\STM32_Nucleo\Inc;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\MDK-ARM;..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Source\STM32\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --no_strict_wchar_size
target NUCLEO_F4_ETSI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: ST_SIGFOX_PB_ETSI_NUCLEO_F4 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xE USE_STM32F4XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ETSI ERASE_VALUE_IS_FF
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --no_strict_wchar_size
target NUCLEO_F4_FCC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: ST_SIGFOX_PB_FCC_NUCLEO_F4 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xE USE_STM32F4XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_FCC ERASE_VALUE_IS_FF
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --no_strict_wchar_size
target NUCLEO_F4_ARIB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: ST_SIGFOX_PB_ARIB_NUCLEO_F4 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xE USE_STM32F4XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ARIB ERASE_VALUE_IS_FF
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --no_strict_wchar_size
target IDB007_ALL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x28000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_ALL_IDB007 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH FOR_ALL BLUENRG1_DEVICE NO_BLE_STACK DEBUG_BLE_NO
  c misc: --diag_suppress=951 --wchar32
  c include: ..\Source;..\MDK-ARM;..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0;..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG1\Include;..\Source\BlueNRG\inc;..\..\..\..\Drivers\BSP\SDK_Eval_BlueNRG1\inc;..\..\..\..\Drivers\BlueNRG1_Periph_Driver\inc;..\..\..\..\Drivers\BSP\SDK_Eval_S2LP_BlueNRG1\inc;..\..\..\..\Drivers\HAL_BLUENRG\inc;..\..\..\..\Drivers\CMSIS\Include;..\..\common\id_key_retriever;..\..\common\st_lowlevel
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --no_strict_wchar_size
target IDB007_ETSI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: ST_SIGFOX_PB_ETSI_IDB007 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH FOR_ARIB BLUENRG1_DEVICE NO_BLE_STACK DEBUG_BLE_NO
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --no_strict_wchar_size
target IDB007_FCC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: ST_SIGFOX_PB_FCC_IDB007 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH FOR_ETSI BLUENRG1_DEVICE NO_BLE_STACK DEBUG_BLE_NO
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --no_strict_wchar_size
target IDB007_ARIB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: ST_SIGFOX_PB_ARIB_IDB007 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH FOR_FCC BLUENRG1_DEVICE NO_BLE_STACK DEBUG_BLE_NO
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --no_strict_wchar_size
target IDB008_ALL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ST_SIGFOX_PB_ALL_IDB008 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH FOR_ALL BLUENRG2_DEVICE NO_BLE_STACK DEBUG_BLE_NO
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  link misc: --no_strict_wchar_size
target IDB008_ETSI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: ST_SIGFOX_PB_ETSI_IDB008 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH FOR_ETSI BLUENRG2_DEVICE NO_BLE_STACK DEBUG_BLE_NO
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  link misc: --no_strict_wchar_size
target IDB008_FCC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: ST_SIGFOX_PB_FCC_IDB008 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH FOR_FCC BLUENRG2_DEVICE NO_BLE_STACK DEBUG_BLE_NO
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  link misc: --no_strict_wchar_size
target IDB008_ARIB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: ST_SIGFOX_PB_ARIB_IDB008 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH FOR_ARIB BLUENRG2_DEVICE NO_BLE_STACK DEBUG_BLE_NO
  c misc: --diag_suppress=951 --wchar32
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  link misc: --no_strict_wchar_size
software components: CMSIS:CORE 5.1.1
