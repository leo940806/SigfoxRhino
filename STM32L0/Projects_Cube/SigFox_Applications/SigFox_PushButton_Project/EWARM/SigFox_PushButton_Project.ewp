# IAR project SigFox_PushButton_Project.ewp, settings and files
configuration NUCLEO_L1_ALL (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ALL
  ICCARM.CCIncludePath2: ..\Source; ..\Source\STM32\inc; ..\..\common\id_key_retriever; ..\..\common\st_lowlevel; ..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0; ..\..\..\..\Middlewares\ST\CLI; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32_Nucleo\Inc; ..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ALL_NUCLEO_L1.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ALL_NUCLEO_L1.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM3\SFX_LIB_V2.5.0_FDL_Cortex_M3.a; ..\..\..\..\Middlewares\Sigfox\CM3\ST_RF_LIB_ALL_CM3.a; ..\..\common\id_key_retriever\CM3\ID_KEY_RETRIEVER_CM3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NUCLEO_L1_ETSI (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L151xBA; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ETSI
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ETSI_NUCLEO_L1.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ETSI_NUCLEO_L1.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM3\SFX_LIB_V2.5.0_FDL_Cortex_M3.a; ..\..\..\..\Middlewares\Sigfox\CM3\ST_RF_LIB_ETSI_CM3.a; ..\..\common\id_key_retriever\CM3\ID_KEY_RETRIEVER_CM3.a
configuration NUCLEO_L1_FCC (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L151xBA; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_FCC
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_FCC_NUCLEO_L1.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_FCC_NUCLEO_L1.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM3\SFX_LIB_V2.5.0_FDL_Cortex_M3.a; ..\..\..\..\Middlewares\Sigfox\CM3\ST_RF_LIB_FCC_CM3.a; ..\..\common\id_key_retriever\CM3\ID_KEY_RETRIEVER_CM3.a
configuration NUCLEO_L1_ARIB (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L151xBA; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ARIB
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ARIB_NUCLEO_L1.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ARIB_NUCLEO_L1.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM3\SFX_LIB_V2.5.0_FDL_Cortex_M3.a; ..\..\..\..\Middlewares\Sigfox\CM3\ST_RF_LIB_ARIB_CM3.a; ..\..\common\id_key_retriever\CM3\ID_KEY_RETRIEVER_CM3.a
configuration NUCLEO_L0_ALL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.CoreVariant: 35
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ALL
  ICCARM.CCIncludePath2: ..\Source; ..\Source\STM32\inc; ..\..\common\id_key_retriever; ..\..\common\st_lowlevel; ..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0; ..\..\..\..\Middlewares\ST\CLI; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32_Nucleo\Inc; ..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Inc
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ALL_NUCLEO_L0.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ALL_NUCLEO_L0.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0PLUS\ST_RF_LIB_ALL_CM0+.a; ..\..\common\id_key_retriever\CM0PLUS\ID_KEY_RETRIEVER_CM0+.a; ..\..\..\..\Middlewares\Sigfox\CM0PLUS\SFX_LIB_V2.5.0_FDL_Cortex_M0+.a
configuration NUCLEO_L0_ETSI (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.CoreVariant: 35
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ETSI
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ETSI_NUCLEO_L0.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ETSI_NUCLEO_L0.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0PLUS\ST_RF_LIB_ETSI_CM0+.a; ..\..\common\id_key_retriever\CM0PLUS\ID_KEY_RETRIEVER_CM0+.a; ..\..\..\..\Middlewares\Sigfox\CM0PLUS\SFX_LIB_V2.5.0_FDL_Cortex_M0+.a
configuration NUCLEO_L0_FCC (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.CoreVariant: 35
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_FCC
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_FCC_NUCLEO_L0.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_FCC_NUCLEO_L0.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0PLUS\ST_RF_LIB_FCC_CM0+.a; ..\..\common\id_key_retriever\CM0PLUS\ID_KEY_RETRIEVER_CM0+.a; ..\..\..\..\Middlewares\Sigfox\CM0PLUS\SFX_LIB_V2.5.0_FDL_Cortex_M0+.a
configuration NUCLEO_L0_ARIB (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.CoreVariant: 35
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ARIB
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ARIB_NUCLEO_L0.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ARIB_NUCLEO_L0.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0PLUS\ST_RF_LIB_ARIB_CM0+.a; ..\..\common\id_key_retriever\CM0PLUS\ID_KEY_RETRIEVER_CM0+.a; ..\..\..\..\Middlewares\Sigfox\CM0PLUS\SFX_LIB_V2.5.0_FDL_Cortex_M0+.a
configuration NUCLEO_F0_ALL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.CoreVariant: 34
  ICCARM.CCDefines: STM32F072xB; USE_STM32F0XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ALL
  ICCARM.CCIncludePath2: ..\Source; ..\Source\STM32\inc; ..\..\common\id_key_retriever; ..\..\common\st_lowlevel; ..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0; ..\..\..\..\Middlewares\ST\CLI; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32_Nucleo\Inc; ..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Inc
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ALL_NUCLEO_F0.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ALL_NUCLEO_F0.out
  ILINK.IlinkIcfFile: stm32f072xb_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0\SFX_LIB_V2.5.0_FDL_Cortex_M0.a; ..\..\..\..\Middlewares\Sigfox\CM0\ST_RF_LIB_ALL_CM0.a; ..\..\common\id_key_retriever\CM0\ID_KEY_RETRIEVER_CM0.a
configuration NUCLEO_F0_ETSI (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.CoreVariant: 34
  ICCARM.CCDefines: STM32F072xB; USE_STM32F0XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ETSI
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ETSI_NUCLEO_F0.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ETSI_NUCLEO_F0.out
  ILINK.IlinkIcfFile: stm32f072xb_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0\SFX_LIB_V2.5.0_FDL_Cortex_M0.a; ..\..\..\..\Middlewares\Sigfox\CM0\ST_RF_LIB_ETSI_CM0.a; ..\..\common\id_key_retriever\CM0\ID_KEY_RETRIEVER_CM0.a
configuration NUCLEO_F0_FCC (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.CoreVariant: 34
  ICCARM.CCDefines: STM32F072xB; USE_STM32F0XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_FCC
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_FCC_NUCLEO_F0.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_FCC_NUCLEO_F0.out
  ILINK.IlinkIcfFile: stm32f072xb_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0\SFX_LIB_V2.5.0_FDL_Cortex_M0.a; ..\..\..\..\Middlewares\Sigfox\CM0\ST_RF_LIB_FCC_CM0.a; ..\..\common\id_key_retriever\CM0\ID_KEY_RETRIEVER_CM0.a
configuration NUCLEO_F0_ARIB (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.CoreVariant: 34
  ICCARM.CCDefines: STM32F072xB; USE_STM32F0XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ARIB
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ARIB_NUCLEO_F0.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ARIB_NUCLEO_F0.out
  ILINK.IlinkIcfFile: stm32f072xb_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0\SFX_LIB_V2.5.0_FDL_Cortex_M0.a; ..\..\..\..\Middlewares\Sigfox\CM0\ST_RF_LIB_ARIB_CM0.a; ..\..\common\id_key_retriever\CM0\ID_KEY_RETRIEVER_CM0.a
configuration NUCLEO_F4_ALL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ALL; ERASE_VALUE_IS_FF
  ICCARM.CCIncludePath2: ..\Source; ..\Source\STM32\inc; ..\..\common\id_key_retriever; ..\..\common\st_lowlevel; ..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0; ..\..\..\..\Middlewares\ST\CLI; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32_Nucleo\Inc; ..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Inc
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_FCC_NUCLEO_F4.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_FCC_NUCLEO_F4.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM4\SFX_LIB_V2.5.0_FDL_Cortex_M4.a; ..\..\..\..\Middlewares\Sigfox\CM4\ST_RF_LIB_ALL_CM4.a; ..\..\common\id_key_retriever\CM4\ID_KEY_RETRIEVER_CM4.a
configuration NUCLEO_F4_ETSI (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ETSI; ERASE_VALUE_IS_FF
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ETSI_NUCLEO_F4.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ETSI_NUCLEO_F4.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM4\SFX_LIB_V2.5.0_FDL_Cortex_M4.a; ..\..\..\..\Middlewares\Sigfox\CM4\ST_RF_LIB_ETSI_CM4.a; ..\..\common\id_key_retriever\CM4\ID_KEY_RETRIEVER_CM4.a
configuration NUCLEO_F4_FCC (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_FCC; ERASE_VALUE_IS_FF
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_FCC_NUCLEO_F4.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_FCC_NUCLEO_F4.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM4\SFX_LIB_V2.5.0_FDL_Cortex_M4.a; ..\..\..\..\Middlewares\Sigfox\CM4\ST_RF_LIB_FCC_CM4.a; ..\..\common\id_key_retriever\CM4\ID_KEY_RETRIEVER_CM4.a
configuration NUCLEO_F4_ARIB (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; USE_SYSTICK_DELAY; FOR_ARIB; ERASE_VALUE_IS_FF
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ARIB_NUCLEO_F4.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ARIB_NUCLEO_F4.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM4\SFX_LIB_V2.5.0_FDL_Cortex_M4.a; ..\..\..\..\Middlewares\Sigfox\CM4\ST_RF_LIB_ARIB_CM4.a; ..\..\common\id_key_retriever\CM4\ID_KEY_RETRIEVER_CM4.a
configuration IDB007_ALL (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.CoreVariant: 34
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; FOR_ALL; BLUENRG1_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO
  ICCARM.CCIncludePath2: ..\Source\; ..\Source\BlueNRG\inc; ..\..\..\..\Drivers\HAL_BLUENRG\inc; ..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\BlueNRG1_Periph_Driver\inc; ..\..\..\..\Drivers\BSP\SDK_Eval_S2LP_BlueNRG1\inc; ..\..\..\..\Drivers\BSP\SDK_Eval_BlueNRG1\inc; ..\..\common\st_lowlevel; ..\..\common\id_key_retriever; ..\..\..\..\Middlewares\Sigfox\sigfox_lib_v.2.5.0
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ALL_IDB007.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ALL_IDB007.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0\ST_RF_LIB_ALL_CM0.a; ..\..\common\id_key_retriever\CM0\ID_KEY_RETRIEVER_CM0.a; ..\..\..\..\Middlewares\Sigfox\CM0\SFX_LIB_V2.5.0_FDL_Cortex_M0.a
configuration IDB007_ETSI (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.CoreVariant: 34
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; FOR_ETSI; BLUENRG1_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ETSI_IDB007.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ETSI_IDB007.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0\ST_RF_LIB_ETSI_CM0.a; ..\..\common\id_key_retriever\CM0\ID_KEY_RETRIEVER_CM0.a; ..\..\..\..\Middlewares\Sigfox\CM0\SFX_LIB_V2.5.0_FDL_Cortex_M0.a
configuration IDB007_FCC (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.CoreVariant: 34
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; FOR_FCC; BLUENRG1_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_FCC_IDB007.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_FCC_IDB007.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0\ST_RF_LIB_FCC_CM0.a; ..\..\common\id_key_retriever\CM0\ID_KEY_RETRIEVER_CM0.a; ..\..\..\..\Middlewares\Sigfox\CM0\SFX_LIB_V2.5.0_FDL_Cortex_M0.a
configuration IDB007_ARIB (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.CoreVariant: 34
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; FOR_ARIB; BLUENRG1_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ARIB_IDB007.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ARIB_IDB007.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Middlewares\Sigfox\CM0\ST_RF_LIB_ARIB_CM0.a; ..\..\common\id_key_retriever\CM0\ID_KEY_RETRIEVER_CM0.a; ..\..\..\..\Middlewares\Sigfox\CM0\SFX_LIB_V2.5.0_FDL_Cortex_M0.a
configuration IDB008_ALL (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.CoreVariant: 34
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; FOR_ALL; BLUENRG2_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ALL_IDB008.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ALL_IDB008.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkAdditionalLibs: as above
configuration IDB008_ETSI (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.CoreVariant: 34
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; FOR_ETSI; BLUENRG2_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ETSI_IDB008.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ETSI_IDB008.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkAdditionalLibs: as above
configuration IDB008_FCC (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.CoreVariant: 34
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; FOR_FCC; BLUENRG2_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_FCC_IDB008.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_FCC_IDB008.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkAdditionalLibs: as above
configuration IDB008_ARIB (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.CoreVariant: 34
  ICCARM.CCDefines: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; FOR_ARIB; BLUENRG2_DEVICE; NO_BLE_STACK; DEBUG_BLE_NO
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: ST_SIGFOX_PB_ARIB_IDB008.bin
  ILINK.IlinkOutputFile: ST_SIGFOX_PB_ARIB_IDB008.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkAdditionalLibs: as above
  group Drivers/BlueNRG-1_Drivers
    ../../../../Drivers/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Drivers/BlueNRG-1_Drivers/HAL
    ../../../../Drivers/HAL_BLUENRG/src/: clock.c context_switch.s osal.c sleep.c
  group Drivers/BSP/SDK_Eval_BlueNRG1
    ../../../../Drivers/BSP/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c
  group Drivers/BSP/SDK_Eval_S2LP_BlueNRG1
    ../../../../Drivers/BSP/SDK_Eval_S2LP_BlueNRG1/src/: S2LP_EVAL_Button.c S2LP_EVAL_Config.c S2LP_EVAL_EEPROM_DMA.c S2LP_EVAL_EMB_FLASH.c S2LP_EVAL_Gpio.c S2LP_EVAL_SPI_DMA.c S2LP_EVAL_Utils.c
  group Drivers/BSP/STM32_NUCLEO
    ../../../../Drivers/BSP/STM32_Nucleo/Src/: SDK_EVAL_Button.c SDK_EVAL_Config.c SDK_EVAL_EEPROM.c SDK_EVAL_EMB_FLASH.c SDK_EVAL_Gpio.c SDK_EVAL_Led.c SDK_EVAL_Spi_Driver_DMA.c SDK_EVAL_Timers.c
  group Drivers/BSP/STM32_NUCLEO_S2LP_Util
    ../../../../Drivers/BSP/Components/S2LP/STM32_Nucleo_S2LP_Util/Src/: S2LP_SDK_Util.c
  group Drivers/CMSIS
    ./: startup_stm32f072xb.s startup_stm32f401xe.s startup_stm32l053xx.s startup_stm32l1xx_hd.s
    ../../../../Drivers/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
    ../Source/STM32/src/: system_stm32f0xx.c system_stm32f4xx.c system_stm32l0xx.c system_stm32l1xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group Source
    ../Source/: hw_config.c main.c
    ../../common/st_lowlevel/: nvm_api.c
  group Source/BlueNRG
    ../Source/BlueNRG/src/: BlueNRG1_it.c
    ../../common/st_lowlevel/: mcu_api_bluenrg1.c
  group Source/STM32
    ../../common/st_lowlevel/: mcu_api.c
    ../Source/STM32/src/: stm32f0xx_it.c stm32f4xx_it.c stm32l0xx_it.c stm32l1xx_it.c
