<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SigFox_PushButton_Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_ALL</name>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_F0_ETSI</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_F0_FCC</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_F4_ETSI</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_F4_FCC</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_L0_ETSI</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_L0_FCC</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_L1_ETSI</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_L1_FCC</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_L0_ARIB</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_F0_ALL</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_F0_ARIB</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_F4_ALL</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_F4_ARIB</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_L0_ALL</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_L1_ALL</configuration>
      </member>
      <member>
        <project>SigFox_PushButton_Project</project>
        <configuration>NUCLEO_L1_ARIB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


